# Autodesk Inventor assembly: 조립품
## iProperties
Created: 2015-01
Part Number: 조립품
Document SubType Name: Assembly
Designer: elite
Author: elite
